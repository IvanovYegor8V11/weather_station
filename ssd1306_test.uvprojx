# Keil uVision project ssd1306_test.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ssd1306_test
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c I2C.c I2C.h SSD1306.c SSD1306.h delay.c delay.h ds18b20.h ds18b20.c GPIO_Init.c GPIO_Init.h DHT22.h DHT22.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
